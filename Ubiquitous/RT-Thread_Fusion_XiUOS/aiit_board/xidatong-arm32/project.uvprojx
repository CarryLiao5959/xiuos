# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.16.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __RTTHREAD__, SKIP_SYSCLK_INIT, CPU_MIMXRT1052CVL5B, USE_RTOS, __CLK_TCK=RT_TICK_PER_SECOND, ENDIANNESS, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\..\..\APP_Framework\Applications\app_test;applications;..\..\..\..\APP_Framework\Applications\general_functions\circular_area;..\..\..\..\APP_Framework\lib\cJSON;..\..\rt-thread\components\libc\compilers\common;..\..\rt-thread\components\libc\compilers\common\extension;..\..\..\..\APP_Framework\Framework\connection;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m7;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;board;board\MCUX_Config;board\ports;board\usb;..\..\rt-thread\bsp\imxrt\libraries\drivers;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\dfs\filesystems\devfs;..\..\rt-thread\components\dfs\filesystems\elmfat;..\..\rt-thread\components\finsh;..\..\..\..\APP_Framework\Framework;.;..\..\rt-thread\include;..\..\rt-thread\components\legacy;..\..\rt-thread\components\legacy\dfs;..\..\rt-thread\bsp\imxrt\libraries\MIMXRT1050\CMSIS\Include;..\..\rt-thread\bsp\imxrt\libraries\MIMXRT1050\MIMXRT1052;..\..\rt-thread\bsp\imxrt\libraries\MIMXRT1050\MIMXRT1052\drivers;..\..\..\..\APP_Framework\Applications\general_functions\list;..\..\..\..\APP_Framework\Framework\knowing\ota;..\..\rt-thread\components\libc\posix\delay;..\..\rt-thread\components\libc\posix\io\poll;..\..\rt-thread\components\libc\posix\io\stdio;..\..\rt-thread\components\libc\posix\ipc;..\..\rt-thread\components\libc\posix\pthreads;..\..\rt-thread\components\drivers\usb\usbhost;..\..\rt-thread\components\drivers\usb\usbhost\class;..\..\rt-thread\components\drivers\usb\usbhost\core;..\..\rt-thread\components\drivers\usb\usbhost\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\net\netdev\include;..\..\rt-thread\components\net\sal\include;..\..\rt-thread\components\net\sal\include\socket;..\..\rt-thread\components\net\sal\include\dfs_net;..\..\rt-thread\components\net\sal\include\socket\sys_socket;..\..\..\..\APP_Framework\Framework\sensor;..\..\..\..\APP_Framework\Framework\sensor\altitude\bmp180;..\..\..\..\APP_Framework\Framework\sensor\ch4\as830;..\..\..\..\APP_Framework\Framework\sensor\co2\g8s;..\..\..\..\APP_Framework\Framework\sensor\co2\zg09;..\..\..\..\APP_Framework\Framework\sensor\hcho\tb600b_wq_hcho1os;..\..\..\..\APP_Framework\Framework\sensor\humidity\hs300x_humi;..\..\..\..\APP_Framework\Framework\sensor\iaq\tb600b_iaq10;..\..\..\..\APP_Framework\Framework\sensor\pm\ps5308;..\..\..\..\APP_Framework\Framework\sensor\temperature\hs300x_temp;..\..\..\..\APP_Framework\Framework\sensor\tvoc\tb600b_tvoc10;..\..\..\..\APP_Framework\Framework\sensor\voice\d124;..\..\..\..\APP_Framework\Framework\sensor\winddirection\qs-fx;..\..\..\..\APP_Framework\Framework\sensor\windspeed\qs-fs;..\..\..\..\APP_Framework\Framework\transform_layer\rtthread;xip
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)
  group app_test
    ../../../../APP_Framework/Applications/app_test/: test_shell.c
  group Applications
    applications/: main.c
  group cjson
    ../../../../APP_Framework/lib/cJSON/: cJSON.c
  group Compiler
    ../../rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../rt-thread/components/libc/compilers/common/: time.c stdlib.c
  group CPU
    ../../rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    ../../rt-thread/components/drivers/cputime/: cputime.c
    ../../rt-thread/components/drivers/ipc/: completion.c pipe.c dataqueue.c waitqueue.c ringblk_buf.c workqueue.c ringbuffer.c
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    ../../rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/ports/: sdcard_port.c
    board/MCUX_Config/: pin_mux.c clock_config.c
    board/: board.c
    ../../rt-thread/bsp/imxrt/libraries/drivers/: drv_gpio.c drv_uart.c drv_sdram.c drv_sdio.c drv_usbh.c
    ../../rt-thread/bsp/imxrt/libraries/drivers/usb/host/: usb_host_hci.c usb_host_framework.c usb_host_ehci.c usb_host_devices.c
    ../../rt-thread/bsp/imxrt/libraries/drivers/usb/phy/: usb_phy.c
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ffunicode.c ff.c
  group Finsh
    ../../rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group framework
    ../../../../APP_Framework/Framework/: framework_init.c
  group Kernel
    ../../rt-thread/src/: device.c memheap.c idle.c components.c ipc.c scheduler.c irq.c timer.c clock.c kservice.c object.c thread.c mempool.c
  group Legacy
    ../../rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    ../../rt-thread/bsp/imxrt/libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
    ../../rt-thread/bsp/imxrt/libraries/MIMXRT1050/MIMXRT1052/drivers/: generic_list.c fsl_gpio.c fsl_lpuart.c fsl_usdhc.c fsl_semc.c fsl_clock.c fsl_xbarb.c fsl_cache.c fsl_common.c fsl_xbara.c fsl_os_abstraction_rtthread.c
    ../../rt-thread/bsp/imxrt/libraries/MIMXRT1050/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group list
    ../../../../APP_Framework/Applications/general_functions/list/: double_list.c single_list.c
  group POSIX
    ../../rt-thread/components/libc/posix/delay/: delay.c
    ../../rt-thread/components/libc/posix/io/stdio/: libc.c
    ../../rt-thread/components/libc/posix/ipc/: mqueue.c semaphore.c
    ../../rt-thread/components/libc/posix/pthreads/: pthread_attr.c pthread.c pthread_barrier.c pthread_mutex.c pthread_spin.c pthread_cond.c sched.c pthread_tls.c pthread_rwlock.c
  group rt_usbh
    ../../rt-thread/components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    ../../rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    ../../rt-thread/components/net/sal/src/: sal_socket.c
    ../../rt-thread/components/net/sal/socket/: net_sockets.c net_netdb.c
    ../../rt-thread/components/net/sal/dfs_net/: dfs_net.c
  group transform
    ../../../../APP_Framework/Framework/transform_layer/rtthread/: transform.c
  group xip
    xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_flash.c
